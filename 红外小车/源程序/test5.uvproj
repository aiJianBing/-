# Keil uVision project test5.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC90C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test5 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 XunJi.c Delay.c main.c motor.c Uart.c
